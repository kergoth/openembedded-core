## meta/conf/distro/include/sdklibc-musl.inc
```bitbake
SDKLIBCEXTENSION = "-${SDKLIBC}"

SDKIMAGE_LINGUAS = ""
BUILDSDK_CXXFLAGS += "-fvisibility-inlines-hidden"
```
